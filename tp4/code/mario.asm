    JMP boot
vslDisplay EQU 0x300

sprite:
    DB "\xFF\xFF\xFF\xFF\xFF\xC4\xC4\xC4"
    DB "\xC4\xC4\xFF\xFF\xFF\xFF\xFF\xFF"
    DB "\xFF\xFF\xFF\xFF\xC4\xC4\xC4\xC4"
    DB "\xC4\xC4\xC4\xC4\xC4\xFF\xFF\xFF"
    DB "\xFF\xFF\xFF\xFF\x8C\x8C\x8C\xF4"
    DB "\xF4\x8C\xF4\xFF\xFF\xFF\xFF\xFF"
    DB "\xFF\xFF\xFF\x8C\xF4\x8C\xF4\xF4"
    DB "\xF4\x8C\xF4\xF4\xF4\xFF\xFF\xFF"
    DB "\xFF\xFF\xFF\x8C\xF4\x8C\x8C\xF4"
    DB "\xF4\xF4\x8C\xF4\xF4\xF4\xFF\xFF"
    DB "\xFF\xFF\xFF\x8C\x8C\xF4\xF4\xF4"
    DB "\xF4\x8C\x8C\x8C\x8C\xFF\xFF\xFF"
    DB "\xFF\xFF\xFF\xFF\xFF\xF4\xF4\xF4"
    DB "\xF4\xF4\xF4\xF4\xFF\xFF\xFF\xFF"
    DB "\xFF\xFF\xFF\xFF\x8C\x8C\xC4\x8C"
    DB "\x8C\x8C\xFF\xFF\xFF\xFF\xFF\xFF"
    DB "\xFF\xFF\xFF\x8C\x8C\x8C\xC4\x8C"
    DB "\x8C\xC4\x8C\x8C\x8C\xFF\xFF\xFF"
    DB "\xFF\xFF\x8C\x8C\x8C\x8C\xC4\xC4"
    DB "\xC4\xC4\x8C\x8C\x8C\x8C\xFF\xFF"
    DB "\xFF\xFF\xF4\xF4\x8C\xC4\xF4\xC4"
    DB "\xC4\xF4\xC4\x8C\xF4\xF4\xFF\xFF"
    DB "\xFF\xFF\xF4\xF4\xF4\xC4\xC4\xC4"
    DB "\xC4\xC4\xC4\xF4\xF4\xF4\xFF\xFF"
    DB "\xFF\xFF\xF4\xF4\xC4\xC4\xC4\xC4"
    DB "\xC4\xC4\xC4\xC4\xF4\xF4\xFF\xFF"
    DB "\xFF\xFF\xFF\xFF\xC4\xC4\xC4\xFF"
    DB "\xFF\xC4\xC4\xC4\xFF\xFF\xFF\xFF"
    DB "\xFF\xFF\xFF\x8C\x8C\x8C\xFF\xFF"
    DB "\xFF\xFF\x8C\x8C\x8C\xFF\xFF\xFF"
    DB "\xFF\xFF\x8C\x8C\x8C\x8C\xFF\xFF"
    DB "\xFF\xFF\x8C\x8C\x8C\x8C\xFF\xFF"
    
boot:
    MOV C, sprite       ; Carga al registro C la imagen.
    MOV D, vslDisplay   ; Puntero de la pantalla

.loop:
    MOVB AL, [C]        ; Mueve al registro A el valor del color actual del valor de C
    CMP A, 0xC4         ; Comparar con el color rojo
    JZ .changeColor     ; Si es rojo, saltamos a changeColor
.paint:
    MOVB [D], AL        ; Coloca el pixel en la posición de la pantalla actual.
    INC C
    INC D
    CMP D, 0x400        ; Verificamos si llegamos al final de la pantalla
    JNZ .loop           ; Si no, volvemos al loop
    HLT

.changeColor:
    MOVB AL, 0x10       ; Color verde al registro AL
    JMP .paint          ; Saltamos a .paint, ahora con el color verde